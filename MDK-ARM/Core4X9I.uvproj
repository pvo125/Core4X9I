# Keil uVision project Core4X9I.uvproj, settings and files
target Core4X9I (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Core4X9I +hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe --bin -o Core4x9I.bin !L
  AfterMake: D:\STM32_проекты\Core4X9I\MDK-ARM\user.bat
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\USER\main;..\MDK-ARM;..\USER;..\USER\GUI;..\USER\GUI_DIALOG;..\USER\SDCARD;..\USER\ssd1963;..\USER\GUI\inc;..\USER\FatFS;..\USER\FatFS\option;..\USER\MX25;..\USER\TSC2046;..\USER\SDRAM;..\USER\PNG;..\USER\Fonts;..\USER\bxCAN
  memory RVCT4: ROM 0x8000000 size 0x35000
  memory RVCT5: ROM 0xd0000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x5000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\USER\Core4X9I.sct
  group startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    ../USER/main/: stm32f4xx_conf.h
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_crc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_exti.c
  group main
    ../USER/main/: main.c template.c stm32f4xx_it.c header.h
  group GUI
    ../USER/GUI/: GUI_X.c GUIConf.c LCDConf.c STemWin522_CM4_Keil.lib
  group GUI_DIALOG
    ../USER/GUI_DIALOG/: Start_WindowDLG.c MENUDLG.c TIMERDLG.c ALARMDLG.c TIME_DATEDLG.c SD_File.c KEYDLG.c PictureView.c
  group FatFS
    ../USER/FatFS/: ff.c diskio.c
    ../USER/FatFS/option/: ccsbcs.c
  group SDCARD
    ../USER/SDCARD/: sdcard.c
  group MX25
    ../USER/MX25/: mx25l8005.c
  group SSD1963
    ../USER/SSD1963/: ssd1963.c
  group TSC2046
    ../USER/TSC2046/: tsc2046.c
  group SDRAM
    ../USER/SDRAM/: SDRAM.c
  group bxCAN
    ../USER/bxCAN/: CAN.c
  group icon
    ../USER/icon/: exit.c photo.c screen.c paint.c next.c prev.c date.c pwm.c sd.c alarm.c AlarmA.c AlarmB.c alarm_d.c add_folder.c del_folder.c bmp.c gif.c jpg.c pdf.c hourglass.c brightness.c
  group Fonts
    ../USER/Fonts/: Arial18.c Arial16.c
